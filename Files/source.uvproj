# Keil uVision project source.uvproj, settings and files
target Source (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: source +hex
  c flags: Optim=1
  c include: Header/
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s
  group Main
    ./src/: delay.c main.c mainFunctions.c
  group Sensors
    ./MQ2/: MQ2.c
    ./LM35/: lm35.c
    ./ADC/: adc.c
  group Interrupt
    ./UART/: Interrupt.c
  group UART
    ./UART/: uart.c
  group I2C
    ./I2C/: I2C.c
  group Keypad
    ./KPM/: kpm.c
  group LCD
    ./LCD/: lcd.c
  group LED
    ./LED/: LED.c
  group GSM
    ./GSM/: GSM.c
  group eeprom
    ./eeprom/: eeprom.c
